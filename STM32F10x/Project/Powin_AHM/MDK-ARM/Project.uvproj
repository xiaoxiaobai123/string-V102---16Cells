# Keil uVision project Project.uvproj, settings and files
target String (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F105_RC +hex
  AfterMake: .\convert2bin.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, RVDS_ARMCM3_LM3S102, PRINTF_USE_UART3,POWIN_AP = 1
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\FreeRTOSV8.1.2\FreeRTOS\Source\include;..\Inc;..\Src\driver;..\Inc\powin;..\..\..\..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Src/: main.c stm32f10x_it.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Driver
    ../Src/driver/: printfdebug.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Src/: system_stm32f10x.c
  group FreeRTOS
    ../../../Libraries/FreeRTOSV8.1.2/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../../Libraries/FreeRTOSV8.1.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../Libraries/FreeRTOSV8.1.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Doc
    ./: readme.txt
  group Powin
    ../Src/powin/: BESS_3-0_AHM_AD7327_V_1-0.c BESS_3-0_AHM_can_V_1-0.c BESS_3-0_AHM_device_lib_V_1-0.c BESS_3-0_AHM_gpio_V_1-0.c BESS_3-0_AHM_mainpowin_V_1-0.c BESS_3-0_AHM_systick_V_1-0.c adc.c contactor.c led.c alarmprocess.c i2c_ee.c booterlib.c canupgrade.c wwdg.c NewStringADC.c DataProcess.c initwork.c relaycontactorctrl.c
    ../../../../Common/src/: BESS_3-0_AHM_canmsg_V_1-0.c BESS_3-0_AHM_config_V_1-0.c
target String_booter (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: STM32F105_RC +hex
  AfterMake: .\convert2binbooter.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, RVDS_ARMCM3_LM3S102, PRINTF_USE_UART3,POWIN_BOOTER,POWIN_AP = 1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target String_normal (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: STM32F105_RC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
